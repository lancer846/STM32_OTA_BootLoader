# Keil uVision project ota_init.uvprojx, settings and files
target OTA (6190000::V6.19::ARMCLANG)
  device: GD32F407VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.2.0
  cpu: IRAM(0x20000000,0x020000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: ota_init +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c misc: -Wno-invalid-source-encoding
  c include: ..\CMSIS\Include;..\Firmware\Include;..\User;..\Lib\usart
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CMSIS
    ../CMSIS/Source/: system_gd32f4xx.c startup_gd32f407_427.s
  group Firmware
    ../Firmware/Source/: gd32f4xx_gpio.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_usart.c gd32f4xx_dma.c
  group User
    ../User/: main.c gd32f4xx_it.c delay.c
  group Lib/usart
    ../Lib/usart/: usart.c
